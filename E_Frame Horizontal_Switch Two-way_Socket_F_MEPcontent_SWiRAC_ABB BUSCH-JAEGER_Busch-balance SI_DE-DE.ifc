Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-10-24T11:44:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 24 11:44:36 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\4a2a7b7e-aaa6-4ace-aaff-4e93a8de6c4c\a87ff425-85ca-4d5d-9bf5-fdaa8571ae73\ifc * Database version: 5507 * Database creation date: Mon Oct 24 11:44:35 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Mon Oct 24 11:44:35 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 24 11:44:35 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: 2CKA001012A1069, E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1069_DE-DE:2CKA001012A1069:1547451
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RGB 150-150-150
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 10 mm; Height: 71 mm; Rounding Radius: 4 mm; Width: 71 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM
Type - Identity Data - Article Code: Default; Article Description: Wippsch.-Eins.up F. Aus; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: yes; Description: Wippsch.-Eins.up F. Aus; EMCS Version: 4.0; ETIM Article Class: EC001590; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395007105; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001012A1069; Manufacturer Type: 2000/6 US; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001012A1069,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Revit Version: 2020; Type Name: 2CKA001012A1069; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1069_DE-DE
Type - Pset_EnvironmentalImpactIndicators - Reference: 2CKA001012A1069
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 2CKA001012A1069
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00701291 m2; Volume: 0.0000522726 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 3; VERSION: 220800
Other - Family: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1069_DE-DE: 2CKA001012A1069; Family and Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1069_DE-DE: 2CKA001012A1069; Type: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1069_DE-DE: 2CKA001012A1069; Type Id: E_Insert_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001012A1069_DE-DE: 2CKA001012A1069
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Busch-balance SI_2CKA001725A1558_hor_2, E_Frame Horizontal_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-DE:Busch-balance SI_2CKA001725A1558_hor_2:1547446
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 15 mm; Gang Height: 56 mm; Gang Width: 56 mm; Height: 81 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 2 mm; Width: 152 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: alpinweiß; Material: Color RAL 9010; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Abdeckrahmen, 2-fach; Article Type: 2-gang frame; Base Family Version: 20221003; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Abdeckrahmen, 2-fach; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 11.17; GLN: 8712507900012; GTIN: 4011395191514; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001725A1558; Manufacturer Type: 1722-914; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001725A1558,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 2-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_2CKA001725A1558_hor_2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame Horizontal_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-DE
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_2CKA001725A1558_hor_2
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Busch-balance SI_2CKA001725A1558_hor_2
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0214287 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.0000580757 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-200 VA
Electrical - Loads - Load Classification: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 220800
Other - Family: E_Frame Horizontal_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-DE: Busch-balance SI_2CKA001725A1558_hor_2; Family and Type: E_Frame Horizontal_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-DE: Busch-balance SI_2CKA001725A1558_hor_2; Gang 3: 71 mm; Gang Reference Line: 127 mm; Interior Width: 28 mm; Number of Representation Line: 2; Type: E_Frame Horizontal_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-DE: Busch-balance SI_2CKA001725A1558_hor_2; Type Id: E_Frame Horizontal_Switch Two-way_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_DE-DE: Busch-balance SI_2CKA001725A1558_hor_2
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Busch-balance SI_with Earth 1F_2CKA002011A6238, E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-DE:Busch-balance SI_with Earth 1F_2CKA002011A6238:1547452
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 2800 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 55 mm; Rounding Radius: 1 mm; Width: 55 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: alpinweiß
Type - Identity Data - Custom: no; Article Code: Default; Article Description: SCHUKO® Steckdose; Article Type: Schuko Steckdose; Base Family Version: 20221003; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Description: SCHUKO® Steckdose; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395191637; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002011A6238; Manufacturer Type: 20 EUCR-914; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA002011A6238,artikel.html; MEPcontent Class: ELECTRICAL_FIXTURES; Model: Schuko Steckdose; OmniClass Number: 23.80.50.00; OmniClass Title: Terminals for Power Supply; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_with Earth 1F_2CKA002011A6238; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-DE
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_with Earth 1F_2CKA002011A6238
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Busch-balance SI_with Earth 1F_2CKA002011A6238
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Moves With Nearby Elements: no; Position Condition: 0; Annotation: 19
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00641861 m2; Volume: 0.0000283672 m3
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 6; VERSION: 220800
Other - Annotation SocketOneFoldWithEarth: yes; Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-DE: Busch-balance SI_with Earth 1F_2CKA002011A6238; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-DE: Busch-balance SI_with Earth 1F_2CKA002011A6238; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-DE: Busch-balance SI_with Earth 1F_2CKA002011A6238; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA002011A6238_DE-DE: Busch-balance SI_with Earth 1F_2CKA002011A6238
Phasing - Phase Created: 4. Plan over 10 years

# IfcSwitchingDevice: Busch-balance SI_2-Way_2CKA001731A2002, E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_DE-DE:Busch-balance SI_2-Way_2CKA001731A2002:1547450
In: F00
Type - PredefinedType: CONTACTOR; Material: Color RAL 9010
Type - Constraints - Default Elevation: 1050 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 11 mm; Height: 55 mm; Rounding Radius: 1 mm; Width: 55 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: alpinweiß
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Wippe, 1-fach; Base Family Version: 20221003; Category: EL_SINGLEPOLESWITCH; Content Supplier URL: www.MEPcontent.com; Description: Wippe, 1-fach; EMCS Version: 4.0; ETIM Article Class: EC000011; Family Version: 11.21; GLN: 8712507900012; GTIN: 4011395190210; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001731A2002; Manufacturer Type: 2506-914; Manufacturer URL: https://www.busch-jaeger-katalog.de/2CKA001731A2002,artikel.html; MEPcontent Class: LIGHTING_DEVICES; OmniClass Number: 23.80.00.00; OmniClass Title: Electric Power and Lighting; Product Line: Busch-balance SI; Revit Version: 2020; Type Name: Busch-balance SI_2-Way_2CKA001731A2002; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Lighting Devices; Family Name: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_DE-DE
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Busch-balance SI_2-Way_2CKA001731A2002
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_SwitchingDeviceTypeCommon - Reference: Busch-balance SI_2-Way_2CKA001731A2002
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 1; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.00781076 m2; Volume: 0.000041523 m3
Identity Data - Copyright: © Trimble Europe BV; Mark: 1; VERSION: 220800
Other - Annotation SwitchTwoWay: yes; Family: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_DE-DE: Busch-balance SI_2-Way_2CKA001731A2002; Family and Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_DE-DE: Busch-balance SI_2-Way_2CKA001731A2002; Type: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_DE-DE: Busch-balance SI_2-Way_2CKA001731A2002; Type Id: E_Switch_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Busch-balance SI_2CKA001731A2002_DE-DE: Busch-balance SI_2-Way_2CKA001731A2002
Phasing - Phase Created: 4. Plan over 10 years
